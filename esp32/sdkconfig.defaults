## esp32/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_SPIFFS_ENABLE=false
CONFIG_LITTLEFS_ENABLE=true
CONFIG_LITTLEFS_SPIFFS_COMPAT=false
```
